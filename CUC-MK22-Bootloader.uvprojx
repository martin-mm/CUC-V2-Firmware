# Keil uVision project CUC-MK22-Bootloader.uvprojx, settings and files
target Target (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MK22FN1M0AVMD12 NXP
  pack: NXP.MK22FA12_DFP.10.0.1
  cpu: IRAM(0x14000000,0x1000) IRAM2(0x1fff0000,0x010000) IROM(0x00000000,0x100000) XRAM(0x20000000,0x010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CUC-MK22 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: DEBUG CPU_MK22FN1M0AVMD12 FSL_RTOS_BM SDK_DEBUGCONSOLE=0 FSL_RTOS_FREE_RTOS SDK_OS_FREE_RTOS TRACEALYZER=1 CUC_HW_V2
  c misc: --protect_stack --diag_suppress=66,1269,186
  c include: .\Source;.\Source\Board;.\Source\NXP-Drivers;.\Source\LowLevelDriver;.\Source\C-Source;.\Source\usb;.\Source\Library;.\Source\CPP-Source;.\Source\Tracealyzer;.\Source\Tracealyzer\config;.\Source\Tracealyzer\include;.\Source\Tracealyzer\streamports\Jlink_RTT\include
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x14000000 size 0x1000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: .\RTE\Device\MK22FN1M0AVMD12\MK22FN1M0Axxx12_flash_bootloader.scf
  group Board
    ./Source/Board/: board.c board.h board-Ana.c board-Ana.h board-DigIO.c board-DigIO.h clock_config.c clock_config.h CUCnewDefs.h peripherals.c peripherals.h pin_mux.c pin_mux.h stdout_user.c
  group Main
    ./Source/CPP-Source/: main.cpp
  group NXP Driver
    ./Source/NXP-Drivers/: fsl_adc16.c fsl_adc16.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_crc.c fsl_crc.h fsl_dac.c fsl_dac.h fsl_dspi.c fsl_dspi.h fsl_flash.c fsl_flash.h fsl_flexcan.c fsl_flexcan.h fsl_ftm.c fsl_ftm.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_llwu.c fsl_llwu.h fsl_lptmr.c fsl_lptmr.h fsl_pdb.c fsl_pdb.h fsl_pit.c fsl_pit.h fsl_port.h fsl_rtc.c fsl_rtc.h fsl_sim.c fsl_sim.h fsl_smc.c fsl_smc.h fsl_sysmpu.c fsl_sysmpu.h fsl_uart.c fsl_uart.h fsl_vref.c fsl_vref.h fsl_wdog.c fsl_wdog.h
  group Low Level Driver
    ./Source/LowLevelDriver/: TMP100.c TMP100.h uart.c uart.h CAN.c CAN.h crc.c crc.h I2C.c I2C.h FRAM.c FRAM.h EEPROM.c EEPROM.h
  group C-Source
    ./Source/C-Source/: CmdDevice.c CmdDevice.h CmdInfo.c CmdInfo.h CmdSystem.c CmdSystem.h CommandDefs.h CommandHandler.c CommandHandler.h CommandMeasure.c CommandMeasure.h common.h EEPROMhandler.c EEPROMhandler.h Misc.c Misc.h System.c System.h
  group CPP-Library
    ./Source/Library/: AnalogInput.cpp AnalogInput.h CANDefs.h CANDriver.cpp CANDriver.h CANNode.cpp CANNode.h EventSource.cpp EventSource.h IO.cpp IO.h MotionGenerator.cpp MotionGenerator.h ProcessData.cpp ProcessData.h PWMDriver.cpp PWMDriver.h Task_CMSIS2.cpp Task_CMSIS2.h Timer.cpp Timer.h UCDevice.cpp UCDevice.h Watchdog.cpp Watchdog.h Base.h IIRfilter.c IIRfilter.h
  group CPP-Source
    ./Source/CPP-Source/: Average.h BoardMgr.cpp BoardMgr.h BrushDevice.cpp BrushDevice.h CAN_Cfg.h CANIds.h CleaningDevice.h CleaningUnit.h CleaningUnitMgr.cpp CleaningUnitMgr.h Debug.h LiftDevice.cpp LiftDevice.h MotorDriver.cpp MotorDriver.h SafetyMgr.cpp SafetyMgr.h SuctionDevice.cpp SuctionDevice.h SvnRevision.h Version.h WaterPumpDevice.cpp WaterPumpDevice.h
  group Tracealyzer
    ./Source/Tracealyzer/: trcKernelPort.c trcSnapshotRecorder.c trcStreamingRecorder.c
    ./Source/Tracealyzer/config/: trcConfig.h trcSnapshotConfig.h trcStreamingConfig.h TracealyzerSetup.h
    ./Source/Tracealyzer/include/: aws_secure_sockets.tzext.h aws_wifi.tzext.h trcExtensions.h trcHardwarePort.h trcKernelPort.h trcPortDefines.h trcRecorder.h
    ./Source/Tracealyzer/streamports/Jlink_RTT/: SEGGER_RTT.c trcStreamingPort.c
    ./Source/Tracealyzer/streamports/Jlink_RTT/include/: SEGGER_RTT.h SEGGER_RTT_Conf.h trcStreamingPort.h
  group USB
    ./Source/usb/: usb.h usb_device.h usb_device_cdc_acm.c usb_device_cdc_acm.h usb_device_ch9.c usb_device_ch9.h usb_device_class.c usb_device_class.h usb_device_config.h usb_device_dci.c usb_device_dci.h usb_device_descriptor.c usb_device_descriptor.h usb_device_khci.c usb_device_khci.h usb_khci.h usb_misc.h usb_osa.h usb_osa_freertos.c usb_osa_freertos.h usb_spec.h virtual_com.c virtual_com.h
software components: RTOS:Config 10.3.1, RTOS:Core 10.3.1, RTOS:Event Groups 10.3.1, RTOS:Heap 10.3.1, RTOS:Timers 10.3.1, CMSIS:CORE 5.4.0, CMSIS:RTOS2:FreeRTOS 10.3.1, Compiler:I/O:STDOUT 1.2.0, Device:Startup 1.0.0
